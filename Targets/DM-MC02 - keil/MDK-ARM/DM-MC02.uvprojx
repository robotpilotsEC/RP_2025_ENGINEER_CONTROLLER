# Keil uVision project DM-MC02.uvprojx, settings and files
target DM-MC02 (6220000::V6.22::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: DM-MC02 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../../../Applications/Algorithm/Include;../../../Applications/Configuration/Include;../../../Applications/Device/Include;../../../Applications/Interface/Include;../../../Applications/Module/Include;../../../Applications/System/Include;../../../Middlewares/FreeRTOS-Kernel/include;../../../Drivers/CMSIS/DSP/Include;../../../Drivers/CMSIS/DSP/PrivateInclude;../BSP;../../../Middlewares/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1;../../../Drivers/BMI08x_SensorAPI;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/Configuration
    ../../../Applications/Configuration/: conf_device.cpp conf_interface.cpp conf_module.cpp conf_process.cpp Configuration.cpp conf_CanTxNode.cpp
  group Application/System
    ../../../Applications/System/Tasks/: sys_task.cpp
    ../../../Applications/System/Core/: Core.cpp
    ../../../Applications/System/: System.cpp
    ../../../Applications/System/Controller_Link/: sys_controller_link.cpp
  group Application/Module
    ../../../Applications/Module/: Module.cpp
  group Application/Module/Controller
    ../../../Applications/Module/Custom_Controller/: com_buzzer.cpp com_rocker.cpp com_roll.cpp com_yaw.cpp mod_controller.cpp proc_controller.cpp com_pitch1.cpp com_pitch2.cpp com_roll_end.cpp com_pitch_end.cpp
  group Application/Algorithm
    ../../../Applications/Algorithm/: algo_crc.cpp algo_pid.cpp algo_other.cpp
  group Application/Device
    ../../../Applications/Device/: Device.cpp dev_rocker.cpp dev_controller_link.cpp
    ../../../Applications/Device/MTR/: motor.cpp mtr_dji.cpp mtr_dm.cpp mtr_kt.cpp
    ../../../Applications/Device/MEMS/: mems.cpp mems_bmi088.cpp
    ../../../Applications/Device/BUZZER/: dev_buzzer.cpp music_lib.cpp
    ../../../Applications/Device/MULTI_BUTTON/: dev_FourButton.cpp dev_multi_button.cpp
  group Application/Interface
    ../../../Applications/Interface/: inf_can.cpp inf_spi.cpp inf_uart.cpp Interface.cpp inf_adc.cpp inf_usb_cdc.cpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c fdcan.c iwdg.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ./: startup_stm32h723xx.s
    ../Core/Src/: system_stm32h7xx.c
  group FreeRTOS
    ../../../Middlewares/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Middlewares/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1/: port.c
  group CMSIS
    ../../../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../../../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../Drivers/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ../../../Drivers/CMSIS/DSP/Source/WindowFunctions/: WindowFunctions.c
  group BSP
    ../BSP/: FreeRTOSConfig.c startup.cpp
    ./: Semihosting.c
  group FreeRTOS/MemMang
    ../../../Middlewares/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
